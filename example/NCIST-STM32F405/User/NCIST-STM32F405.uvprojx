# Keil uVision project NCIST-STM32F405.uvprojx, settings and files
target NCIST-STM32F405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NCIST-STM32F405
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT
  c include: ..\User;..\System\include;..\System\Core;..\System\CMSIS;..\System\FWLib\inc;..\System\FreeRTOS\include;..\System\FreeRTOS\portable\RVDS\ARM_CM4F;..\Devices\led;..\Task\led;..\Drivers\USART;..\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group Task
    ../Task/led/: task_led.c
  group Devices
    ../Devices/led/: led.c
  group Drivers
    ../Drivers/USART/: usart.c
  group System/include
    ../System/include/: sys.c delay.c
  group System/Core
    ../System/Core/: startup_stm32f40_41xxx.s
  group System/CMSIS
    ../System/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group System/FWLib
    ../System/FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System/FreeRTOS_Core
    ../System/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group System/FreeRTOS_Portable
    ../System/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../System/FreeRTOS/portable/MemMang/: heap_4.c
  group IMU
    ../IMU/: IMU_task.c IMU.c Matrix.c IIR_Filter.c Smooth_Filter.c MPU9250.c MPU_SPI.c pid.c arm_cortexM4lf_math.lib
